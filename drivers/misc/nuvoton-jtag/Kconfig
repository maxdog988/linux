## drivers/misc/nuvoton-jtag/Kconfig
```kconfig
config NUVOTON_JTAG
	tristate "Jtag master driver"
	default n
	help
	  Jtag master driver.
```
